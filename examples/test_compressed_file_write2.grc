<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_compressed_file_write2</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>600e3</value></param>
</block>
<block>
<key>compress_CompressedFileSink</key>
<param><key>id</key><value>compress_CompressedFileSink_0</value></param>
<param><key>append</key><value>False</value></param>
<param><key>file</key><value>/opt/tmp/Recordings/ATA/M3OH_y_small_104.8576MSPS.bc.gr.zstd</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>compress_compress</key>
<param><key>id</key><value>compress_compress_0</value></param>
<param><key>addheader</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>numThreads</key><value>4</value></param>
</block>
<block>
<key>filerepeater_file_repeater_ex</key>
<param><key>id</key><value>filerepeater_file_repeater_ex_0</value></param>
<param><key>complexconv</key><value>0</value></param>
<param><key>delayFirstStart</key><value>0.0</value></param>
<param><key>file</key><value>/opt/tmp/Recordings/ATA/M3OH_y_small_104.8576MSPS.bc</value></param>
<param><key>repeat_times</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>repeat_delay</key><value>0</value></param>
</block>
<connection><source_block_id>compress_compress_0</source_block_id><sink_block_id>compress_CompressedFileSink_0</sink_block_id><source_key>compressed</source_key><sink_key>compressedin</sink_key></connection>
<connection><source_block_id>filerepeater_file_repeater_ex_0</source_block_id><sink_block_id>compress_compress_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
