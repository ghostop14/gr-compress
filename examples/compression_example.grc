<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>compression_example</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>600e3</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/opt/sdr/gnuradio/gnuradio_recordings/NOAA_weather_radio_162.425MHz_NBFM_600KSPS_48KFilter.iq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>compress_CompressedFileSink</key>
<param><key>id</key><value>compress_CompressedFileSink_0</value></param>
<param><key>append</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value></value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>compress_CompressedFileSource</key>
<param><key>id</key><value>compress_CompressedFileSource_0</value></param>
<param><key>begin_tag</key><value>pmt.PMT_NIL</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value></value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>compress_compress</key>
<param><key>id</key><value>compress_compress_0</value></param>
<param><key>addheader</key><value>False</value></param>
<param><key>blocksize</key><value>64000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>numThreads</key><value>4</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>compress_decompress</key>
<param><key>id</key><value>compress_decompress_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>sendmsg</key><value>False</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Network-based</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>File Save</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1</value></param>
<param><key>note</key><value>Regular File Source</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0</value></param>
<param><key>note</key><value>Compressed File Source</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>zeromq_pull_msg_source</key>
<param><key>id</key><value>zeromq_pull_msg_source_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:2000</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_push_msg_sink</key>
<param><key>id</key><value>zeromq_push_msg_sink_0</value></param>
<param><key>address</key><value>tcp://*:2000</value></param>
<param><key>comment</key><value>Listen for connections</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>compress_compress_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>compress_CompressedFileSource_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>compress_compress_0</source_block_id><sink_block_id>compress_CompressedFileSink_0</sink_block_id><source_key>compressed</source_key><sink_key>compressedin</sink_key></connection>
<connection><source_block_id>compress_compress_0</source_block_id><sink_block_id>zeromq_push_msg_sink_0</sink_block_id><source_key>compressed</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>compress_decompress_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_msg_source_0</source_block_id><sink_block_id>compress_decompress_0</sink_block_id><source_key>out</source_key><sink_key>compressedin</sink_key></connection>
</flow_graph>
