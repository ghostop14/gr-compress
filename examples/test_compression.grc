<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_compression</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>600e3</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>48000</value></param>
<param><key>max_dev</key><value>5e3</value></param>
<param><key>quad_rate</key><value>480000</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>compress_CompressedMsgToStream</key>
<param><key>id</key><value>compress_CompressedMsgToStream_0</value></param>
</block>
<block>
<key>compress_StreamToDecompressionMsg</key>
<param><key>id</key><value>compress_StreamToDecompressionMsg_0</value></param>
</block>
<block>
<key>compress_compress</key>
<param><key>id</key><value>compress_compress_0</value></param>
<param><key>addheader</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>numThreads</key><value>4</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>compress_decompress</key>
<param><key>id</key><value>compress_decompress_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>sendmsg</key><value>False</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>filerepeater_file_repeater_ex</key>
<param><key>id</key><value>filerepeater_file_repeater_ex_0</value></param>
<param><key>comment</key><value>Float Complex Data</value></param>
<param><key>complexconv</key><value>0</value></param>
<param><key>delayFirstStart</key><value>0.0</value></param>
<param><key>file</key><value>/opt/sdr/gnuradio/gnuradio_recordings/NOAA_weather_radio_162.425MHz_NBFM_600KSPS_NoFilter.iq</value></param>
<param><key>repeat_times</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>repeat_delay</key><value>0</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_3_0</value></param>
<param><key>cutoff_freq</key><value>3e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>3e3*0.2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>interp</key><value>4</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>compress_compress_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>compress_CompressedMsgToStream_0</source_block_id><sink_block_id>compress_StreamToDecompressionMsg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>compress_StreamToDecompressionMsg_0</source_block_id><sink_block_id>compress_decompress_0</sink_block_id><source_key>compressed</source_key><sink_key>compressedin</sink_key></connection>
<connection><source_block_id>compress_compress_0</source_block_id><sink_block_id>compress_CompressedMsgToStream_0</sink_block_id><source_key>compressed</source_key><sink_key>compressed</sink_key></connection>
<connection><source_block_id>compress_decompress_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>compress_decompress_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>filerepeater_file_repeater_ex_0</source_block_id><sink_block_id>low_pass_filter_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_3_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>analog_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
