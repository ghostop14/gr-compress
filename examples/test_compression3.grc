<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_compression3</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>104.8576e6</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate*2</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>compress_CompressedMsgToStream</key>
<param><key>id</key><value>compress_CompressedMsgToStream_0</value></param>
</block>
<block>
<key>compress_StreamToDecompressionMsg</key>
<param><key>id</key><value>compress_StreamToDecompressionMsg_0</value></param>
</block>
<block>
<key>compress_compress</key>
<param><key>id</key><value>compress_compress_0</value></param>
<param><key>addheader</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>numThreads</key><value>4</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>compress_decompress</key>
<param><key>id</key><value>compress_decompress_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>sendmsg</key><value>False</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>filerepeater_file_repeater_ex</key>
<param><key>id</key><value>filerepeater_file_repeater_ex_0</value></param>
<param><key>comment</key><value>USRP Complex Int16 File</value></param>
<param><key>complexconv</key><value>0</value></param>
<param><key>delayFirstStart</key><value>0.0</value></param>
<param><key>file</key><value>/media/mpiscopo/18d6f16c-02e7-4056-9f85-042e4c546179/Recordings/Voyager/voyager-58620.311555.16ic</value></param>
<param><key>repeat_times</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>repeat_delay</key><value>0</value></param>
</block>
<block>
<key>grnet_Int16BytesToComplex</key>
<param><key>id</key><value>grnet_Int16BytesToComplex_0</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>If this block shows missing install gr-grnet</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>compress_compress_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>compress_CompressedMsgToStream_0</source_block_id><sink_block_id>compress_StreamToDecompressionMsg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>compress_StreamToDecompressionMsg_0</source_block_id><sink_block_id>compress_decompress_0</sink_block_id><source_key>compressed</source_key><sink_key>compressedin</sink_key></connection>
<connection><source_block_id>compress_compress_0</source_block_id><sink_block_id>compress_CompressedMsgToStream_0</sink_block_id><source_key>compressed</source_key><sink_key>compressed</sink_key></connection>
<connection><source_block_id>compress_decompress_0</source_block_id><sink_block_id>grnet_Int16BytesToComplex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>filerepeater_file_repeater_ex_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>grnet_Int16BytesToComplex_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
